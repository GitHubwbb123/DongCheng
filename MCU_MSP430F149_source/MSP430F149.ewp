# IAR project MSP430F149.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Gizwits; Hal\Hal_Usart; Hal\Hal_key; User; Utils
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  group (top)
    Utils/: common.c common.h dataPointTools.c dataPointTools.h ringbuffer.c ringBuffer.h
    Gizwits/: gizwits_product.c gizwits_product.h gizwits_protocol.c gizwits_protocol.h
    Hal/Hal_key/: Hal_key.c Hal_key.h
    Hal/Hal_Usart/: hal_uart.c hal_uart.h
    User/: main.c
